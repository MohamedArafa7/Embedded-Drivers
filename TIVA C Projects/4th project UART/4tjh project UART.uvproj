# Keil uVision project 4tjh project UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: 4tjh project UART
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: mian.c UART.c ExtInterrupt.c ExtInterrupt.h GPIO.c GPIO.h LCD4.c LCD4.h MyBoard.c MyBoard.h startup.s tm4c123gh6pm.h UART.h
